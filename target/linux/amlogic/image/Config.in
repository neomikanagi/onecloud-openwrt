## target/linux/amlogic/image/Config.in
```kconfig
config TARGET_KERNEL_PARTSIZE
	int
	default 24

config TARGET_ROOTFS_PARTSIZE
	int
	default 512
```
